# Keil uVision project FSP_Project.uvprojx, settings and files
target Target 1 (6240000::V6.24::.\ArmCompilerforEmbedded6.24)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.5.6.0
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: cpkhmi_mipi +hex
  c flags: Optim=5 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c misc: @via/rasc_armclang.via
  c include: .\src\SEGGER_RTT;.
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via
  group Source Group 1
    ./src/: arm_2d_scene_bubble_charging.c arm_2d_scene_bubble_charging.h
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c board_sdram.c board_sdram.h common_utils.h mipi_dsi_ep.c mipi_dsi_ep.h
    ./src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: Acceleration:Arm-2D Demos:AudioMark 1.0.3, Acceleration:Arm-2D Demos:Basics 1.4.0, Acceleration:Arm-2D Demos:Compass 1.2.1, Acceleration:Arm-2D Demos:Decoding JPG with TJpgDec 1.0.0, Acceleration:Arm-2D Demos:Filters 1.2.1, Acceleration:Arm-2D Demos:Matrix 1.1.0, Acceleration:Arm-2D Demos:Progress and Status 2.1.0, Acceleration:Arm-2D Demos:Text Reader 0.9.1, Acceleration:Arm-2D Demos:Transform 2.1.1, Acceleration:Arm-2D Demos:Watch Face 01 1.2.0, Acceleration:Arm-2D Extras:Controls 2.6.1, Acceleration:Arm-2D Extras:LCD ASCII Printf 2.11.1, Acceleration:Arm-2D Extras:Loaders 2.1.1, Acceleration:Arm-2D Helper:Display Adapter 3.3.9, Acceleration:Arm-2D Helper:PFB 2.7.0, Acceleration:Arm-2D:Alpha-Blending 1.2.2-rc, Acceleration:Arm-2D:Core 1.2.2-rc, Acceleration:Arm-2D:Filter 1.2.2-rc, Acceleration:Arm-2D:Transform 1.2.2-rc, CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2, Utilities:perf_counter:Core 2.4.0, Flex Software:RA Configuration 1.0.0
